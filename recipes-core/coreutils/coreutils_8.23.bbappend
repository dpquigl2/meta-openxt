DEPENDS += "libselinux"
EXTRA_OECONF += "--with-selinux"

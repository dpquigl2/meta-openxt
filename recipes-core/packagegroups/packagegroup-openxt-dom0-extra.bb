# TODO: This file looks pretty unneeded to me.

DESCRIPTION = "Extra packages required for OpenXT dom0"
LICENSE = "Proprietary"
PR = "r14"

inherit packagegroup

RDEPENDS_${PN} = " \
"

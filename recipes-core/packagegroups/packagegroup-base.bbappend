PR = "openxt-01"

RDEPENDS_packagegroup-base-keyboard = "\
    kbd \
    openxt-console-keymaps"

PR = "openxt-01"

DEPENDS += " polkit libpam "

PACKAGECONFIG_append = " policykit pam "

FILESEXTRAPATHS_append := "${THISDIR}/${PN}"
SRC_URI += "file://minimal-settings-helper.patch"

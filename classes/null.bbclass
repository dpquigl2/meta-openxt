# Empty class. (Used in openxt-src-package and openxt-image-src-package.)

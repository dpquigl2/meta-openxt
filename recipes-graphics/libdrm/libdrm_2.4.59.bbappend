SRC_URI += "file://libdrm-foreign.patch"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

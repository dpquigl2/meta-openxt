EXTRA_OECONF += "--enable-wide-chars"



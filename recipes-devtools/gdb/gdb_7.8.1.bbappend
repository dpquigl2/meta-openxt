EXTRA_OECONF += "--enable-tui"


